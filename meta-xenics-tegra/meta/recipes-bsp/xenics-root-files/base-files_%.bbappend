
do_install_append () {
    rm ${D}${sysconfdir}/issue
}
