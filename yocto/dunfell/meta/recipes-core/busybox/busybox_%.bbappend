SRC_URI += "file://fragment.cfg;subdir=busybox-1.31.1"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
