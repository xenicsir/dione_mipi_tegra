SRC_URI += "file://fragment.cfg;subdir=busybox-1.31.1"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
