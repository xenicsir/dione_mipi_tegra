do_install:append () {
    rm ${D}${sysconfdir}/issue
}
