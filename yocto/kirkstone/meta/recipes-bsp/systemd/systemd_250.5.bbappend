FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0002-cgroup-downgrade-warning-if-we-cant-get-ID-off-cgroup.patch"
